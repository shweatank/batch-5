# Keil uVision project arm_practise.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: interrupt_workshop +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s lcd.h lcd_defines.h defines.h delay.c delay.h seg.c ca7seg_test.c ca_mux_7seg.c seg_defines.h seg.h assignment2_lcd6.c lcd_workshop.c assignment2_lcd7.c types.h interrupt_workshop.c pin_connect_block.c
    ./practise-again-main/: adc.c lcd.c
